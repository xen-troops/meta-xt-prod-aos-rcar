
IMAGE_INSTALL_append = " \
    xen \
    xen-network \
    xen-tools-devd \
    xen-tools-scripts-network \
    xen-tools-scripts-block \
    xen-tools-xenstore \
    dnsmasq \
    optee-os \
    block \
"

