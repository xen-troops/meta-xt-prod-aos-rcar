COMPATIBLE_HOST = "aarch64.*-linux"

IMAGE_NAME = "initramfs-domd"

PACKAGE_INSTALL = " \
    busybox \
"
