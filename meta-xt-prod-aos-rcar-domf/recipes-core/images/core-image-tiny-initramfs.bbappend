COMPATIBLE_HOST = "aarch64.*-linux"

IMAGE_NAME = "initramfs-domf"

PACKAGE_INSTALL = " \
    busybox \
"
